<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\aria_qs_9x60_ek_tm5000_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
